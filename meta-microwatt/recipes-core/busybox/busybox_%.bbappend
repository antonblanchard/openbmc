FILESEXTRAPATHS_prepend_witherspoon-microwatt := "${THISDIR}/files:"
SRC_URI_append_witherspoon-microwatt = " file://microwatt-busybox.cfg"
